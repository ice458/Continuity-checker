v {xschem version=3.4.2 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 340 -220 590 -220 {
lab=vdd}
N 390 160 420 160 {
lab=#net1}
N 660 260 660 280 {
lab=#net2}
N 660 180 660 200 {
lab=#net3}
N 660 340 660 360 {
lab=#net4}
N 660 350 720 350 {
lab=#net4}
N 720 350 720 380 {
lab=#net4}
N 720 380 810 380 {
lab=#net4}
N 660 190 720 190 {
lab=#net3}
N 720 160 720 190 {
lab=#net3}
N 660 230 690 230 {
lab=vdd}
N 690 150 690 230 {
lab=vdd}
N 660 150 690 150 {
lab=vdd}
N 660 150 690 150 {
lab=vdd}
N 780 190 810 190 {
lab=vdd}
N 660 -220 770 -220 {
lab=vdd}
N 660 310 690 310 {
lab=gnd}
N 690 310 690 440 {
lab=gnd}
N 660 440 690 440 {
lab=gnd}
N 660 420 660 440 {
lab=gnd}
N 660 390 690 390 {
lab=gnd}
N 780 350 810 350 {
lab=gnd}
N 850 190 850 350 {
lab=#net2}
N 660 270 850 270 {
lab=#net2}
N 850 230 880 230 {
lab=#net2}
N 850 310 880 310 {
lab=#net2}
N 920 260 920 280 {
lab=#net5}
N 920 270 970 270 {
lab=#net5}
N 770 -220 910 -220 {
lab=vdd}
N 920 230 950 230 {
lab=vdd}
N 950 170 950 230 {
lab=vdd}
N 920 170 950 170 {
lab=vdd}
N 920 310 950 310 {
lab=gnd}
N 690 440 950 440 {
lab=gnd}
N 760 220 810 220 {
lab=gnd}
N 760 220 760 440 {
lab=gnd}
N 920 340 920 440 {
lab=gnd}
N 810 260 810 320 {
lab=vdd}
N 750 260 810 260 {
lab=vdd}
N 750 -70 750 260 {
lab=vdd}
N 350 440 690 440 {
lab=gnd}
N 320 160 350 160 {
lab=gnd}
N 460 160 540 160 {
lab=gnd}
N 540 160 540 440 {
lab=gnd}
N 660 -70 660 120 {
lab=vdd}
N 150 -220 340 -220 {
lab=vdd}
N 460 10 460 20 {
lab=#net6}
N 590 -220 660 -220 {
lab=vdd}
N 580 150 620 150 {
lab=#net6}
N 580 230 620 230 {
lab=#net6}
N 580 310 620 310 {
lab=#net6}
N 580 280 580 310 {
lab=#net6}
N 580 390 620 390 {
lab=#net6}
N 580 310 580 390 {
lab=#net6}
N 810 150 810 160 {
lab=#net3}
N 720 150 810 150 {
lab=#net3}
N 720 150 720 160 {
lab=#net3}
N 350 100 350 130 {
lab=#net1}
N 350 110 350 130 {
lab=#net1}
N 350 110 410 110 {
lab=#net1}
N 410 110 410 160 {
lab=#net1}
N 320 70 350 70 {
lab=vdd}
N 460 20 460 70 {
lab=#net6}
N 320 -70 320 70 {
lab=vdd}
N 390 70 410 70 {
lab=#net1}
N 410 70 410 110 {
lab=#net1}
N 350 -70 350 -40 {
lab=vdd}
N 320 -10 350 -10 {
lab=vdd}
N 350 20 350 40 {
lab=#net7}
N 350 30 410 30 {
lab=#net7}
N 410 -10 410 30 {
lab=#net7}
N 390 -10 410 -10 {
lab=#net7}
N 970 90 970 270 {
lab=#net5}
N 460 60 500 60 {
lab=#net6}
N 550 0 580 0 {
lab=vdd}
N 550 -100 550 0 {
lab=vdd}
N 580 -50 580 -30 {
lab=#net8}
N 550 -80 580 -80 {
lab=vdd}
N 580 -160 580 -110 {
lab=vdd}
N 350 190 350 260 {
lab=gnd}
N 350 320 350 440 {
lab=gnd}
N 350 260 350 320 {
lab=gnd}
N 410 280 410 440 {
lab=gnd}
N 460 190 460 200 {
lab=#net9}
N 460 200 500 200 {
lab=#net9}
N 500 200 500 230 {
lab=#net9}
N 410 230 410 280 {
lab=gnd}
N 410 230 460 230 {
lab=gnd}
N 460 260 500 260 {
lab=#net10}
N 500 260 500 290 {
lab=#net10}
N 460 320 460 370 {
lab=p}
N 410 290 460 290 {
lab=gnd}
N 1200 -80 1220 -80 {
lab=vdd}
N 1280 -80 1300 -80 {
lab=vdd}
N 1200 -80 1200 -60 {
lab=vdd}
N 1280 -80 1280 -60 {
lab=vdd}
N 1130 -30 1160 -30 {
lab=out2}
N 1220 -80 1220 -30 {
lab=vdd}
N 1200 -30 1220 -30 {
lab=vdd}
N 1300 -80 1300 -30 {
lab=vdd}
N 1280 -30 1300 -30 {
lab=vdd}
N 1200 0 1200 20 {
lab=#net11}
N 1280 0 1280 20 {
lab=#net11}
N 1200 20 1280 20 {
lab=#net11}
N 1280 20 1360 20 {
lab=#net11}
N 1240 -30 1240 30 {
lab=#net2}
N 1150 30 1240 30 {
lab=#net2}
N 1200 20 1200 40 {
lab=#net11}
N 1150 30 1150 70 {
lab=#net2}
N 1080 70 1150 70 {
lab=#net2}
N 1150 70 1160 70 {
lab=#net2}
N 1200 70 1220 70 {
lab=gnd}
N 1200 100 1200 120 {
lab=#net12}
N 1130 -30 1130 150 {
lab=out2}
N 1130 150 1160 150 {
lab=out2}
N 1220 70 1220 150 {
lab=gnd}
N 1200 150 1220 150 {
lab=gnd}
N 1200 180 1200 190 {
lab=gnd}
N 1220 150 1220 190 {
lab=gnd}
N 1200 190 1220 190 {
lab=gnd}
N 1200 190 1200 210 {
lab=gnd}
N 1390 150 1410 150 {
lab=vdd}
N 1470 150 1490 150 {
lab=vdd}
N 1390 150 1390 170 {
lab=vdd}
N 1470 150 1470 170 {
lab=vdd}
N 1320 200 1350 200 {
lab=out1}
N 1410 150 1410 200 {
lab=vdd}
N 1390 200 1410 200 {
lab=vdd}
N 1490 150 1490 200 {
lab=vdd}
N 1470 200 1490 200 {
lab=vdd}
N 1390 230 1390 250 {
lab=#net13}
N 1470 230 1470 250 {
lab=#net13}
N 1390 250 1470 250 {
lab=#net13}
N 1470 250 1550 250 {
lab=#net13}
N 1430 200 1430 260 {
lab=#net2}
N 1340 260 1430 260 {
lab=#net2}
N 1390 250 1390 270 {
lab=#net13}
N 1340 260 1340 300 {
lab=#net2}
N 1340 300 1350 300 {
lab=#net2}
N 1390 300 1410 300 {
lab=gnd}
N 1390 330 1390 350 {
lab=#net14}
N 1320 200 1320 380 {
lab=out1}
N 1320 380 1350 380 {
lab=out1}
N 1410 300 1410 380 {
lab=gnd}
N 1390 380 1410 380 {
lab=gnd}
N 1390 410 1390 420 {
lab=gnd}
N 1410 380 1410 420 {
lab=gnd}
N 1390 420 1410 420 {
lab=gnd}
N 1390 420 1390 440 {
lab=gnd}
N 950 440 1390 440 {
lab=gnd}
N 1200 210 1200 440 {
lab=gnd}
N 1720 -90 1740 -90 {
lab=vdd}
N 1800 -90 1820 -90 {
lab=vdd}
N 1720 -90 1720 -70 {
lab=vdd}
N 1800 -90 1800 -70 {
lab=vdd}
N 1650 -40 1680 -40 {
lab=out2}
N 1740 -90 1740 -40 {
lab=vdd}
N 1720 -40 1740 -40 {
lab=vdd}
N 1820 -90 1820 -40 {
lab=vdd}
N 1800 -40 1820 -40 {
lab=vdd}
N 1720 -10 1720 10 {
lab=out1}
N 1800 -10 1800 10 {
lab=out1}
N 1720 10 1800 10 {
lab=out1}
N 1800 10 1880 10 {
lab=out1}
N 1760 -40 1760 20 {
lab=#net11}
N 1670 20 1760 20 {
lab=#net11}
N 1720 10 1720 30 {
lab=out1}
N 1670 20 1670 60 {
lab=#net11}
N 1670 60 1680 60 {
lab=#net11}
N 1720 60 1740 60 {
lab=gnd}
N 1720 90 1720 110 {
lab=#net15}
N 1650 -40 1650 140 {
lab=out2}
N 1650 140 1680 140 {
lab=out2}
N 1740 60 1740 140 {
lab=gnd}
N 1720 140 1740 140 {
lab=gnd}
N 1720 170 1720 180 {
lab=gnd}
N 1740 140 1740 180 {
lab=gnd}
N 1720 180 1740 180 {
lab=gnd}
N 1720 180 1720 200 {
lab=gnd}
N 1910 140 1930 140 {
lab=vdd}
N 1930 140 1990 140 {
lab=vdd}
N 1990 140 2010 140 {
lab=vdd}
N 1910 140 1910 160 {
lab=vdd}
N 1990 140 1990 160 {
lab=vdd}
N 1840 190 1870 190 {
lab=#net13}
N 1930 140 1930 190 {
lab=vdd}
N 1910 190 1930 190 {
lab=vdd}
N 2010 140 2010 190 {
lab=vdd}
N 1990 190 2010 190 {
lab=vdd}
N 1910 220 1910 240 {
lab=out2}
N 1990 220 1990 240 {
lab=out2}
N 1910 240 1990 240 {
lab=out2}
N 1990 240 2070 240 {
lab=out2}
N 1950 190 1950 250 {
lab=out1}
N 1860 250 1950 250 {
lab=out1}
N 1910 240 1910 260 {
lab=out2}
N 1860 250 1860 290 {
lab=out1}
N 1790 290 1860 290 {
lab=out1}
N 1860 290 1870 290 {
lab=out1}
N 1910 290 1930 290 {
lab=gnd}
N 1910 320 1910 340 {
lab=#net16}
N 1840 190 1840 370 {
lab=#net13}
N 1840 370 1870 370 {
lab=#net13}
N 1930 290 1930 370 {
lab=gnd}
N 1910 370 1930 370 {
lab=gnd}
N 1910 400 1910 410 {
lab=gnd}
N 1930 370 1930 410 {
lab=gnd}
N 1910 410 1930 410 {
lab=gnd}
N 1720 200 1720 430 {
lab=gnd}
N 1800 100 1800 190 {
lab=out2}
N 1800 100 2070 100 {
lab=out2}
N 2070 100 2070 240 {
lab=out2}
N 1780 140 1780 290 {
lab=out1}
N 1780 290 1790 290 {
lab=out1}
N 1390 440 1910 440 {
lab=gnd}
N 1910 420 1910 440 {
lab=gnd}
N 1720 430 1720 440 {
lab=gnd}
N 1360 20 1600 20 {
lab=#net11}
N 1270 90 1580 90 {
lab=out2}
N 1040 300 1340 300 {
lab=#net2}
N 1040 70 1040 300 {
lab=#net2}
N 1040 70 1080 70 {
lab=#net2}
N 1270 90 1270 240 {
lab=out2}
N 1130 240 1270 240 {
lab=out2}
N 1130 150 1130 240 {
lab=out2}
N 1320 380 1320 500 {
lab=out1}
N 2010 -150 2010 160 {
lab=vdd}
N 1580 90 1600 90 {
lab=out2}
N 1780 290 1780 500 {
lab=out1}
N 1320 500 1780 500 {
lab=out1}
N 460 70 460 130 {
lab=#net6}
N 500 60 520 60 {
lab=#net6}
N 580 150 580 280 {
lab=#net6}
N 1040 300 1040 490 {
lab=#net2}
N 870 510 1040 510 {
lab=#net2}
N 870 310 870 510 {
lab=#net2}
N 580 -40 620 -40 {
lab=#net8}
N 620 -80 620 -40 {
lab=#net8}
N 580 120 580 150 {
lab=#net6}
N 770 350 780 350 {
lab=gnd}
N 350 -220 350 -70 {
lab=vdd}
N 580 30 580 120 {
lab=#net6}
N 520 60 580 60 {
lab=#net6}
N 620 0 970 0 {
lab=#net5}
N 970 0 970 90 {
lab=#net5}
N 580 -220 580 -160 {
lab=vdd}
N 660 -220 660 -70 {
lab=vdd}
N 750 -220 750 -70 {
lab=vdd}
N 1040 490 1040 510 {
lab=#net2}
N 920 -220 920 200 {
lab=vdd}
N 910 -220 920 -220 {
lab=vdd}
N 920 -220 2010 -220 {
lab=vdd}
N 2010 -220 2010 -150 {
lab=vdd}
N 1200 -220 1200 -80 {
lab=vdd}
N 1280 -210 1280 -80 {
lab=vdd}
N 1280 -220 1280 -210 {
lab=vdd}
N 1390 -220 1390 150 {
lab=vdd}
N 1470 -220 1470 150 {
lab=vdd}
N 1720 -220 1720 -90 {
lab=vdd}
N 1800 -220 1800 -90 {
lab=vdd}
N 1910 410 1910 420 {
lab=gnd}
N 150 440 350 440 {
lab=gnd}
N 1550 250 1840 250 {
lab=#net13}
N 1600 90 1650 90 {
lab=out2}
N 1650 140 1650 190 {
lab=out2}
N 1650 190 1800 190 {
lab=out2}
N 1600 20 1670 20 {
lab=#net11}
N 320 -70 350 -70 {
lab=vdd}
N 550 -130 550 -100 {
lab=vdd}
N 550 -130 580 -130 {
lab=vdd}
N 690 100 690 150 {
lab=vdd}
N 660 100 690 100 {
lab=vdd}
N 750 190 780 190 {
lab=vdd}
N 320 160 320 220 {
lab=gnd}
N 320 220 350 220 {
lab=gnd}
N 760 350 770 350 {
lab=gnd}
N 950 310 950 360 {
lab=gnd}
N 920 360 950 360 {
lab=gnd}
N 380 -140 500 -140 {
lab=vdd}
N 460 -220 460 -140 {
lab=vdd}
N 380 -100 500 -100 {
lab=#net6}
N 460 -100 460 10 {
lab=#net6}
N 1880 10 1910 10 {
lab=out1}
N 2070 160 2090 160 {
lab=out2}
N 1780 10 1780 140 {
lab=out1}
N 1910 10 2090 10 {
lab=out1}
N 460 370 460 460 {
lab=p}
N 460 460 460 510 {
lab=p}
C {NMOS_MIN.sym} 420 160 0 0 {name=M4 model=nch w=10u l=10u as=0 ps=0 ad=0 pd=0 m=1}
C {PMOS_MIN.sym} 620 0 0 1 {name=M5 model=pch w=40u l=10u as=0 ps=0 ad=0 pd=0 m=1}
C {PMOS_MIN.sym} 620 150 0 0 {name=M6 model=pch w=40u l=10u as=0 ps=0 ad=0 pd=0 m=1}
C {PMOS_MIN.sym} 620 230 0 0 {name=M7 model=pch w=40u l=10u as=0 ps=0 ad=0 pd=0 m=1}
C {NMOS_MIN.sym} 620 310 0 0 {name=M8 model=nch w=10u l=10u as=0 ps=0 ad=0 pd=0 m=1}
C {NMOS_MIN.sym} 620 390 0 0 {name=M9 model=nch w=10u l=10u as=0 ps=0 ad=0 pd=0 m=1}
C {NMOS_MIN.sym} 850 350 0 1 {name=M10 model=nch w=10u l=10u as=0 ps=0 ad=0 pd=0 m=1}
C {PMOS_MIN.sym} 850 190 0 1 {name=M11 model=pch w=40u l=10u as=0 ps=0 ad=0 pd=0 m=1}
C {PMOS_MIN.sym} 880 230 0 0 {name=M12 model=pch w=40u l=10u as=0 ps=0 ad=0 pd=0 m=1}
C {NMOS_MIN.sym} 880 310 0 0 {name=M13 model=nch w=10u l=10u as=0 ps=0 ad=0 pd=0 m=1}
C {cap.sym} 370 -140 0 0 {name=C1
m=1
value=0.41p
footprint=1206
device=ceramic}
C {NMOS_MIN.sym} 390 160 0 1 {name=M1 model=nch w=10u l=10u as=0 ps=0 ad=0 pd=0 m=1}
C {PMOS_MIN.sym} 390 70 0 1 {name=M14 model=pch w=40u l=10u as=0 ps=0 ad=0 pd=0 m=1}
C {PMOS_MIN.sym} 390 -10 0 1 {name=M2 model=pch w=40u l=10u as=0 ps=0 ad=0 pd=0 m=1}
C {PMOS_MIN.sym} 620 -80 0 1 {name=M15 model=pch w=40u l=10u as=0 ps=0 ad=0 pd=0 m=1}
C {NMOS_MIN.sym} 500 230 0 1 {name=M16 model=nch w=10u l=10u as=0 ps=0 ad=0 pd=0 m=1}
C {NMOS_MIN.sym} 500 290 0 1 {name=M17 model=nch w=10u l=10u as=0 ps=0 ad=0 pd=0 m=1}
C {PMOS_MIN.sym} 1160 -30 0 0 {name=M18 l=10.0U w=40.0U}
C {PMOS_MIN.sym} 1240 -30 0 0 {name=M19 l=10.0U w=40.0U}
C {NMOS_MIN.sym} 1160 70 0 0 {name=M20 l=10.0U w=10.0U}
C {NMOS_MIN.sym} 1160 150 0 0 {name=M21 l=10.0U w=10.0U}
C {PMOS_MIN.sym} 1350 200 0 0 {name=M22 l=10.0U w=40.0U}
C {PMOS_MIN.sym} 1430 200 0 0 {name=M23 l=10.0U w=40.0U}
C {NMOS_MIN.sym} 1350 300 0 0 {name=M24 l=10.0U w=10.0U}
C {NMOS_MIN.sym} 1350 380 0 0 {name=M25 l=10.0U w=10.0U}
C {PMOS_MIN.sym} 1680 -40 0 0 {name=M26 l=10.0U w=40.0U}
C {PMOS_MIN.sym} 1760 -40 0 0 {name=M27 l=10.0U w=40.0U}
C {NMOS_MIN.sym} 1680 60 0 0 {name=M28 l=10.0U w=10.0U}
C {NMOS_MIN.sym} 1680 140 0 0 {name=M29 l=10.0U w=10.0U}
C {PMOS_MIN.sym} 1870 190 0 0 {name=M30 l=10.0U w=40.0U}
C {PMOS_MIN.sym} 1950 190 0 0 {name=M31 l=10.0U w=40.0U}
C {NMOS_MIN.sym} 1870 290 0 0 {name=M32 l=10.0U w=10.0U}
C {NMOS_MIN.sym} 1870 370 0 0 {name=M33 l=10.0U w=10.0U}
C {cap.sym} 410 -140 0 0 {name=C2
m=1
value=0.41p
footprint=1206
device=ceramic}
C {cap.sym} 450 -140 0 0 {name=C3
m=1
value=0.41p
footprint=1206
device=ceramic}
C {cap.sym} 490 -140 0 0 {name=C4
m=1
value=0.41p
footprint=1206
device=ceramic}
C {iopin.sym} 150 440 2 0 {name=p6 lab=gnd}
C {iopin.sym} 150 -220 2 0 {name=p9 lab=vdd
}
C {iopin.sym} 460 510 1 0 {name=p10 lab=p
}
C {opin.sym} 2090 160 0 0 {name=p3 lab=out2
}
C {opin.sym} 2090 10 0 0 {name=p4 lab=out1}
C {cap.sym} 500 -370 0 0 {name=C5
m=1
value=0.41p
footprint=1206
device=ceramic}
C {cap.sym} 550 -370 0 0 {name=C6
m=1
value=0.41p
footprint=1206
device=ceramic}
C {cap.sym} 600 -370 0 0 {name=C7
m=1
value=0.41p
footprint=1206
device=ceramic}
C {cap.sym} 650 -370 0 0 {name=C8
m=1
value=0.41p
footprint=1206
device=ceramic}
C {cap.sym} 700 -370 0 0 {name=C9
m=1
value=0.41p
footprint=1206
device=ceramic}
C {cap.sym} 750 -370 0 0 {name=C10
m=1
value=0.41p
footprint=1206
device=ceramic}
C {cap.sym} 800 -370 0 0 {name=C11
m=1
value=0.41p
footprint=1206
device=ceramic}
C {cap.sym} 850 -370 0 0 {name=C12
m=1
value=0.41p
footprint=1206
device=ceramic}
C {cap.sym} 900 -370 0 0 {name=C13
m=1
value=0.41p
footprint=1206
device=ceramic}
C {cap.sym} 950 -370 0 0 {name=C14
m=1
value=0.41p
footprint=1206
device=ceramic}
C {cap.sym} 1000 -370 0 0 {name=C15
m=1
value=0.41p
footprint=1206
device=ceramic}
C {cap.sym} 1050 -370 0 0 {name=C16
m=1
value=0.41p
footprint=1206
device=ceramic}
